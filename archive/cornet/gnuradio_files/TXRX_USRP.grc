options:
  parameters:
    author: Cameron Makin
    copyright: Wireless@VT
    description: Uses 1 USRP to TX and RX on different channels
    generate_options: qt_gui
    id: TXRX_USRP
    output_language: python
    title: Full-Duplex TX and RX USRP
  states: {}

blocks:
- name: X310_ip_address
  id: variable
  parameters:
    value: '"addr=192.168.40.203"'
  states: {}
- name: bins
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: bw
  id: variable_qtgui_range
  parameters:
    label: bandwidth
    orient: Qt.Horizontal
    start: '1000000'
    step: '100000'
    stop: '9000000'
    value: '5000000'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: center_freq
    orient: Qt.Horizontal
    start: '913000000'
    step: '100000'
    stop: '917000000'
    value: '915000000'
  states: {}
- name: gain_rx_id
  id: variable_qtgui_range
  parameters:
    label: gain_rx
    orient: Qt.Horizontal
    start: '0'
    step: '0.5'
    stop: '34'
    value: '0'
  states: {}
- name: gain_tx_id
  id: variable_qtgui_range
  parameters:
    label: gain_tx
    orient: Qt.Horizontal
    start: '0'
    step: '0.5'
    stop: '32'
    value: '31.5'
  states: {}
- name: rx_bw
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: src_amp
  id: variable_qtgui_range
  parameters:
    label: Signal Source Amplitude
    min_len: '10'
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: src_amp
    noise_type: analog.GR_UNIFORM
    seed: '0'
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: bins
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: bins
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: bins
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: bins
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(bins)
  states: {}
- name: rx_probe
  id: blocks_probe_signal_vx
  parameters:
    type: float
    vlen: bins
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: bw
    center_freq0: fc
    clock_rate: 200e6
    dev_addr: X310_ip_address
    dev_args: '"A:"'
    gain0: gain_tx_id
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: bw
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: rx_bw
    center_freq0: fc
    dc_offs_enb0: '""'
    dev_addr: X310_ip_address
    dev_args: '"B:"'
    gain0: gain_rx_id
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: rx_bw
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_noise_source_x_0, '0', uhd_usrp_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', rx_probe, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_usrp_source_1, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
